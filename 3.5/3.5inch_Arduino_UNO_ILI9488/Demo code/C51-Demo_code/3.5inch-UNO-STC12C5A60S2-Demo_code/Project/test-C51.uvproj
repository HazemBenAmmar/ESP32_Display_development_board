# Keil uVision project test-C51.uvproj, settings and files
target TFT-TEST (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: test-C51 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\sys;..\USER;..\HARDWARE\LCD;..\HARDWARE\touch
  group USER
    ../USER/: main.c test.c gui.c
  group SYSTEM
    ../sys/: sys.c STARTUP.A51
  group HARDWARE
    ../HARDWARE/LCD/: LCD.c
    ../HARDWARE/touch/: touch.c
